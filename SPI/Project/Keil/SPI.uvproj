# Keil uVision project SPI.uvproj, settings and files
target Basic-DMA (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Basic-DMA +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\Project;..\..\Lib\STM32F10x_StdPeriph_Driver\inc;..\..\Lib\CMSIS\CM3\CoreSupport;..\..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib
    ../../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_dma.c
  group User
    ../: main.c stm32f10x_it.c system_stm32f10x.c debug.h Redirect_fput.c Redirect_fput.h FIFO.c function.c function.h
    ../../Lib/STM32F10x_StdPeriph_Driver/src/: debug.c stm32f10x_exti.c
